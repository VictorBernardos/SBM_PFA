# Keil uVision project P5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P5
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: Thread.c main.c ldc.c lcd.h Arial12x12.h joystick.c joystick.h Thread.h sensorTemp.c sensorTemp.h buzzer.c buzzer.h led_rgb.c led_rgb.h
software components: CMSIS Driver:I2C:Custom 2.3.0, CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:I2C 2.5.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
